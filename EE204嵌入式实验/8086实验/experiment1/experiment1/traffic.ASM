PortOut	EQU	88h	;定义输出端口号
X1 EQU 33H
Y1 EQU 37H
X2 EQU 1EH
Y2 EQU 3EH

BLINK1 PROC FAR
	 MOV AL,X1
	 OUT PortOut,AL
	 MOV CX 1000
	 LOOP $		;DELAY
	 MOV AL,Y1
	 OUT PortOut,AL
	 MOV CX 1000
	 LOOP $		;DELAY
	 RET
ENDP

BLINK2 PROC FAR	
	 MOV AL,X2
	 OUT PortOut,AL
	 MOV CX 1000
	 LOOP $		;DELAY
	 MOV AL,Y2
	 OUT PortOut,AL
	 MOV CX 1000
	 LOOP $		;DELAY
	 RET
ENDP

MAIN PROC FAR
	 MOV AL,36H
	 OUT PortOut,AL
	 MOV CX 10000
	 LOOP $		;DELAY
	 MOV AL,33H
	 OUT PortOut,AL
	 CALL BLINK1
	 MOV AL,35H
	 OUT PortOut,AL
	 MOV CX 10000
	 LOOP $		;DELAY
	 MOV AL,1EH
	 OUT PortOut,AL
	 CALL BLINK2
	 MOV AL,35H
	 OUT PortOut,AL
	 MOV CX 10000
	 LOOP $		;DELAY
	 RET
MAIN ENDP