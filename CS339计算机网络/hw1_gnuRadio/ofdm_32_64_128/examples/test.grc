<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>FFTsize</value></param>
<param><key>value</key><value>64</value></param>
<param><key>label0</key><value>64</value></param>
<param><key>label1</key><value>32</value></param>
<param><key>label2</key><value>128</value></param>
<param><key>label</key><value>number of subcarriers</value></param>
<param><key>num_opts</key><value>3</value></param>
<param><key>option0</key><value>64</value></param>
<param><key>option1</key><value>32</value></param>
<param><key>option2</key><value>128</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>delay</value></param>
<param><key>value</key><value>48</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dev_id_0</value></param>
<param><key>value</key><value>"name=NI290101"</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>drate</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>Data rate</value></param>
<param><key>labels</key><value>['6Mbps','9Mbps','12Mbps','18Mbps','24Mbps','36Mbps','48Mbps','54Mbps']</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>[0, 1, 2,3,4,5,6,7]</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_data_0</value></param>
<param><key>value</key><value>915e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>0.1</value></param>
<param><key>label</key><value>RX gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>rx_rrc_taps</value></param>
<param><key>alpha</key><value>0.35</value></param>
<param><key>gain</key><value>32</value></param>
<param><key>ntaps</key><value>11*4*32</value></param>
<param><key>samp_rate</key><value>32*4</value></param>
<param><key>sym_rate</key><value>1.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_0</value></param>
<param><key>value</key><value>2e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps_0</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>value</key><value>0.6</value></param>
<param><key>label</key><value>TX gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>tx_rrc_taps</value></param>
<param><key>alpha</key><value>0.35</value></param>
<param><key>gain</key><value>sps</value></param>
<param><key>ntaps</key><value>11*sps</value></param>
<param><key>samp_rate</key><value>sps</value></param>
<param><key>sym_rate</key><value>1.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_subdev</value></param>
<param><key>value</key><value>"A:A"</value></param>
</block>
<block>
<key>blocks_conjugate_cc</key>
<param><key>id</key><value>blocks_conjugate_cc_0</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>delay</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/home/forsworn/Desktop/test.out</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>host</key><value>127.0.0.1</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>8000</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_SERVER"</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_2</value></param>
<param><key>host</key><value>127.0.0.1</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>8001</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_CLIENT"</value></param>
</block>
<block>
<key>digital_pfb_clock_sync_xxx</key>
<param><key>id</key><value>digital_pfb_clock_sync_xxx_0</value></param>
<param><key>filter_size</key><value>nfilts</value></param>
<param><key>init_phase</key><value>nfilts/2</value></param>
<param><key>loop_bw</key><value>2*pi/200</value></param>
<param><key>max_dev</key><value>1.5</value></param>
<param><key>osps</key><value>1</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>taps</key><value>rx_rrc_taps</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>fft_size</key><value>FFTsize</value></param>
<param><key>forward</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>False</value></param>
<param><key>window</key><value></value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_1</value></param>
<param><key>fft_size</key><value>FFTsize</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>False</value></param>
<param><key>window</key><value></value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from math import sin, pi</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0</value></param>
<param><key>interp</key><value>sps</value></param>
<param><key>taps</key><value>tx_rrc_taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>wifi_ofdm_v2_block_decoder_vc</key>
<param><key>id</key><value>wifi_ofdm_v2_block_decoder_vc_0</value></param>
<param><key>FFTsize</key><value>64</value></param>
</block>
<block>
<key>wifi_ofdm_v2_coarse_cfo_fixer_cc</key>
<param><key>id</key><value>wifi_ofdm_v2_coarse_cfo_fixer_cc_0</value></param>
<param><key>delay</key><value>16</value></param>
</block>
<block>
<key>wifi_ofdm_v2_cp_preamble_prefixer_vcc</key>
<param><key>id</key><value>wifi_ofdm_v2_cp_preamble_prefixer_vcc_0</value></param>
<param><key>FFTsize</key><value>64</value></param>
<param><key>tag</key><value>"packet_len"</value></param>
</block>
<block>
<key>wifi_ofdm_v2_header_prefixer</key>
<param><key>id</key><value>wifi_ofdm_v2_header_prefixer_0</value></param>
<param><key>FFTsize</key><value>64</value></param>
</block>
<block>
<key>wifi_ofdm_v2_ppdu_builder</key>
<param><key>id</key><value>wifi_ofdm_v2_ppdu_builder_0</value></param>
<param><key>FFTsize</key><value>64</value></param>
<param><key>rate</key><value>0</value></param>
<param><key>seed</key><value>255</value></param>
</block>
<block>
<key>wifi_ofdm_v2_ppdu_sink</key>
<param><key>id</key><value>wifi_ofdm_v2_ppdu_sink_0</value></param>
</block>
<block>
<key>wifi_ofdm_v2_symbol_mapper_bvc</key>
<param><key>id</key><value>wifi_ofdm_v2_symbol_mapper_bvc_0</value></param>
<param><key>tag</key><value>"packet_len"</value></param>
</block>
<block>
<key>wifi_ofdm_v2_symbol_parser_vc</key>
<param><key>id</key><value>wifi_ofdm_v2_symbol_parser_vc_0</value></param>
<param><key>FFTsize</key><value>64</value></param>
</block>
<block>
<key>wifi_ofdm_v2_symbol_sync_cvc</key>
<param><key>id</key><value>wifi_ofdm_v2_symbol_sync_cvc_0</value></param>
<param><key>FFTsize</key><value>64</value></param>
</block>
<connection><source_block_id>blocks_conjugate_cc_0</source_block_id><sink_block_id>wifi_ofdm_v2_coarse_cfo_fixer_cc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>blocks_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>wifi_ofdm_v2_symbol_mapper_bvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_socket_pdu_0</source_block_id><sink_block_id>wifi_ofdm_v2_ppdu_builder_0</sink_block_id><source_key>pdus</source_key><sink_key>plcp_in</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0</source_block_id><sink_block_id>wifi_ofdm_v2_coarse_cfo_fixer_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>wifi_ofdm_v2_cp_preamble_prefixer_vcc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_1</source_block_id><sink_block_id>wifi_ofdm_v2_symbol_parser_vc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>digital_pfb_clock_sync_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wifi_ofdm_v2_block_decoder_vc_0</source_block_id><sink_block_id>wifi_ofdm_v2_ppdu_sink_0</sink_block_id><source_key>ppdu_out</source_key><sink_key>ppdu_in</sink_key></connection>
<connection><source_block_id>wifi_ofdm_v2_coarse_cfo_fixer_cc_0</source_block_id><sink_block_id>wifi_ofdm_v2_symbol_sync_cvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wifi_ofdm_v2_cp_preamble_prefixer_vcc_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wifi_ofdm_v2_header_prefixer_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>ppdu_out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>wifi_ofdm_v2_ppdu_builder_0</source_block_id><sink_block_id>wifi_ofdm_v2_header_prefixer_0</sink_block_id><source_key>ppdu_out</source_key><sink_key>psdu_in</sink_key></connection>
<connection><source_block_id>wifi_ofdm_v2_ppdu_sink_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>msg_out</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>wifi_ofdm_v2_ppdu_sink_0</source_block_id><sink_block_id>blocks_socket_pdu_2</sink_block_id><source_key>msg_out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>wifi_ofdm_v2_symbol_mapper_bvc_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wifi_ofdm_v2_symbol_parser_vc_0</source_block_id><sink_block_id>wifi_ofdm_v2_block_decoder_vc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wifi_ofdm_v2_symbol_sync_cvc_0</source_block_id><sink_block_id>fft_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
